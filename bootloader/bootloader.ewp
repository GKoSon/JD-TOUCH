# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L471RE ST STM32L471RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L471xx; BOOTLOADER
  ICCARM.IExtraOptions: -f ..\Src\config.cfg
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ..\components; ..\components\ins; ..\utilities; ..\bsp\ins; ..\bsp; ..\module; ..\module\ins; ..\module\buletooth\BB0906; ..\module\spi_flash; ..\Middlewares\Third_Party\nanopb; ..\applications\buletooth\model; ..\applications\buletooth\before; ..\Middlewares\Third_Party\mbedtls-2.6.0\include; ..\components\cryption; ..\components\sys_cfg; ..\components\component; ..\components\cryption\aes; ..\components\cryption\crc16; ..\components\cryption\crc32; ..\components\cryption\EncryDecry; ..\components\buletooth; ..\module\module; ..\components\beep; ..\components\twinkle; ..\bsp\gpio; ..\components\timer; ..\components\open_door; ..\module\relay; ..\module\config_key; ..\module\door_key; ..\applications\key; ..\module\keyboard\CY8CMBR3116; ..\bsp\i2c; ..\components\tempwd; ..\bsp\rtc; ..\module\magnet; ..\module\card\st95hf\lib\inc; ..\module\card\st95hf\drv; ..\bsp\spi; ..\applications\swipe; ..\components\list; ..\components\log; ..\applications\net; ..\module\net\gsm\sim800c; ..\components\socket; ..\components\err_log; ..\module\rs485\SN75176BDR; ..\components\rs485; ..\bsp\chipFlash; ..\module\spi_flash\bootloader; ..\applications\card; ..\components\tagComp; ..\components\permi_list; ..\applications\mqtt; ..\Middlewares\Third_Party\mqtt\MQTTPacket\src; ..\applications\QRCode; ..\components\mate; ..\components\sysCntSave
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32l471xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group application/EWARM
    ./: startup_stm32l471xx.s stm32l471xx_flash.icf
  group application/User
    ../Src/: adc.c config.cfg fatfs.c flash_fat_dev.c freertos.c gpio.c iwdg.c rtc.c spi.c stm32l4xx_hal_msp.c tim.c usart.c user_diskio.c
    ../components/bootloader/: bootloader_main.c bootloader_stm32l4xx_it.c
  group bsp/chipFlash
    ../bsp/chipFlash/: chipFlash.c chipFlash.h
  group bsp/rtc
    ../bsp/rtc/: bsp_rtc.c bsp_rtc.h
  group bsp/serial
    ../bsp/serial/: serial.c serial.h
  group bsp/spi
    ../bsp/spi/: hal_spi.c hal_spi.h
  group components/cryption/crc16
    ../components/cryption/crc16/: crc16.c crc16.h
  group components/cryption/crc32
    ../components/cryption/crc32/: crc32.c crc32.h
  group Drivers/CMSIS
    ../components/bootloader/: bootloader_system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c
  group modules/spi_flash
    ../module/spi_flash/bootloader/: bl_spi_flash.c bl_spi_flash.h flash_sector.c flash_sector.h
  group utilities
    ../utilities/: unit.c unit.h
