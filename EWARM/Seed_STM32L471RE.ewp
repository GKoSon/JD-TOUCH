# IAR project Seed_STM32L471RE.ewp, settings and files
configuration Seed_STM32L471RE (ARM, debug)
  General.OGChipSelectEditMenu: STM32L471RE ST STM32L471RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L471xx
  ICCARM.IExtraOptions: -f ..\Src\config.cfg
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc; ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ..\components; ..\components\ins; ..\utilities; ..\bsp\ins; ..\bsp; ..\module; ..\module\ins; ..\module\buletooth\BB0906; ..\module\spi_flash; ..\Middlewares\Third_Party\nanopb; ..\applications\buletooth\model; ..\applications\buletooth\before; ..\Middlewares\Third_Party\mbedtls-2.6.0\include; ..\components\cryption; ..\components\sys_cfg; ..\components\component; ..\components\cryption\aes; ..\components\cryption\crc16; ..\components\cryption\crc32; ..\components\cryption\EncryDecry; ..\components\buletooth; ..\module\module; ..\components\beep; ..\components\twinkle; ..\bsp\gpio; ..\components\timer; ..\components\open_door; ..\module\relay; ..\module\config_key; ..\module\door_key; ..\applications\key; ..\module\keyboard\CY8CMBR3116; ..\bsp\i2c; ..\components\tempwd; ..\bsp\rtc; ..\module\magnet; ..\module\card\st95hf\lib\inc; ..\module\card\st95hf\drv; ..\bsp\spi; ..\components\list; ..\components\permi_list; ..\components\log; ..\applications\net; ..\module\net\gsm\sim800c; ..\components\socket; ..\components\cm_backtrace; ..\components\err_log; ..\module\Backlight; ..\components\ladder; ..\module\rs485\SN75176BDR; ..\bsp\serial; ..\components\rs485; ..\module\buletooth\BM77; ..\module\net\wifi\esp12s; ..\module\net\eth\w5500\drv; ..\module\net\eth\w5500\lib\DHCP; ..\module\net\eth\w5500\lib\dns; ..\module\net\eth\w5500\lib\w5500; ..\module\net\eth\w5500\lib\socket; ..\module\net\eth\w5500\lib; ..\bsp\chipFlash; ..\bsp\pwm; ..\module\card\st25r3911b\inc; ..\module\card\st25r3911b\components; ..\module\card\st25r3911b\Src; ..\applications\card; ..\components\tagComp; ..\module\card\st25r3911b\drv; ..\Middlewares\Third_Party\mqtt\MQTTPacket\src; ..\applications\mqtt; ..\Middlewares\Third_Party\mbedtls-2.6.0\include\mbedtls; ..\components\cryption\hmac_sha1; ..\components\cryption\digest; ..\applications\mqtt\model; ..\Middlewares\Third_Party\STM32_Cryptographic_Library\inc; ..\Middlewares\Third_Party\STM32_Cryptographic_Library\inc\RSA; ..\components\sys_led; ..\components\sysCntSave; ..\Middlewares\Third_Party\cjson; D:\TSBrowserDownloads\JD-TOUCH\components\GMD5
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: application.hex
  postbuild: ..\Tool\CombineBootloaderAndApplication.exe ..\bootloader\Debug\Exe\bootloader.hex Seed_STM32L471RE\Exe\application.hex Seed_STM32L471RE\Exe\JDTOUCH_V1.hex
  ILINK.IlinkOutputFile: Seed_STM32L471RE.out
  ILINK.IlinkIcfFile: stm32l471xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration QRcode (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc; ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ..\components; ..\components\ins; ..\utilities; ..\bsp\ins; ..\bsp; ..\module; ..\module\ins; ..\module\buletooth\BB0906; ..\module\spi_flash; ..\Middlewares\Third_Party\nanopb; ..\applications\buletooth\model; ..\applications\buletooth\before; ..\Middlewares\Third_Party\mbedtls-2.6.0\include; ..\components\cryption; ..\components\sys_cfg; ..\components\component; ..\components\cryption\aes; ..\components\cryption\crc16; ..\components\cryption\crc32; ..\components\cryption\EncryDecry; ..\components\buletooth; ..\module\module; ..\components\beep; ..\components\twinkle; ..\bsp\gpio; ..\components\timer; ..\components\open_door; ..\module\relay; ..\module\config_key; ..\module\door_key; ..\applications\key; ..\module\keyboard\CY8CMBR3116; ..\bsp\i2c; ..\components\tempwd; ..\bsp\rtc; ..\module\magnet; ..\module\card\st95hf\lib\inc; ..\module\card\st95hf\drv; ..\bsp\spi; ..\components\list; ..\components\permi_list; ..\components\log; ..\applications\net; ..\module\net\gsm\sim800c; ..\components\socket; ..\components\cm_backtrace; ..\components\err_log; ..\module\Backlight; ..\components\ladder; ..\module\rs485\SN75176BDR; ..\bsp\serial; ..\components\rs485; ..\module\buletooth\BM77; ..\module\net\wifi\esp12s; ..\module\net\eth\w5500\drv; ..\module\net\eth\w5500\lib\DHCP; ..\module\net\eth\w5500\lib\dns; ..\module\net\eth\w5500\lib\w5500; ..\module\net\eth\w5500\lib\socket; ..\module\net\eth\w5500\lib; ..\bsp\chipFlash; ..\bsp\pwm; ..\module\card\st25r3911b\inc; ..\module\card\st25r3911b\components; ..\module\card\st25r3911b\Src; ..\applications\card; ..\components\tagComp; ..\module\card\st25r3911b\drv; ..\Middlewares\Third_Party\mqtt\MQTTPacket\src; ..\applications\mqtt; ..\Middlewares\Third_Party\mbedtls-2.6.0\include\mbedtls; ..\components\cryption\hmac_sha1; ..\components\cryption\digest; ..\applications\mqtt\model; ..\Middlewares\Third_Party\STM32_Cryptographic_Library\inc; ..\Middlewares\Third_Party\STM32_Cryptographic_Library\inc\RSA; ..\components\sys_led; ..\applications\QRCode; ..\components\mate; ..\components\sysCntSave
  postbuild: ..\Tool\CombineBootloaderAndApplication.exe ..\bootloader\Debug\Exe\bootloader.hex QRcode\Exe\application.hex QRcode\Exe\Seed-V200_QRCODE_BTEA.hex
  group Application/buletooth/before
    ../applications/buletooth/before/: BleDataHandle.c BleDataHandle.h btTask.c
  group Application/buletooth/model
    ../applications/buletooth/model/: BleProtocol.pb.c BleProtocol.pb.h
  group Application/card
    ../applications/card/: card.c card.h swipeTag.c swipeTag.h tslDatahand.c tslDatahand.h
  group Application/EWARM
    ./: startup_stm32l471xx.s stm32l471xx_flash.icf
  group Application/key
    ../applications/key/: key_task.c key_task.h
  group Application/mqtt
    ../applications/mqtt/: mqtt_client.c mqtt_client.h mqtt_ota.c mqtt_ota.h mqtt_task.c mqtt_task.h MQTTFreeRTOS.c MQTTFreeRTOS.h tsl_mqtt.c tsl_mqtt.h
  group Application/User
    ../Src/: adc.c config.cfg freertos.c gpio.c iwdg.c main.c rtc.c spi.c stm32l4xx_hal_msp.c stm32l4xx_it.c tim.c usart.c variable.c
    ../Inc/: config.h FreeRTOSConfig.h stm32l4xx_hal_conf.h
  group bsp
    ../bsp/ins/: bsp.h
  group bsp/chipFlash
    ../bsp/chipFlash/: chipFlash.c chipFlash.h
  group bsp/gpio
    ../bsp/gpio/: bsp_gpio.c bsp_gpio.h
  group bsp/i2c
    ../bsp/i2c/: i2c.c i2c.h
  group bsp/pwm
    ../bsp/pwm/: pwm.c pwm.h
  group bsp/rtc
    ../bsp/rtc/: bsp_rtc.c bsp_rtc.h
  group bsp/serial
    ../bsp/serial/: serial.c serial.h
  group bsp/spi
    ../bsp/spi/: hal_spi.c hal_spi.h
  group components
    ../components/ins/: components_ins.h
  group components/beep
    ../components/beep/: beep.c beep.h
  group components/buletooth
    ../components/buletooth/: buletooth.c buletooth.h
  group components/cm_backtrace
    ../components/cm_backtrace/: cm_backtrace.c
    ../components/cm_backtrace/fault_handler/iar/: cmb_fault.S
  group components/component
    ../components/component/: component.c component.h
  group components/console
    ../components/console/: console.c console.h
  group components/cryption/aes
    ../Middlewares/Third_Party/mbedtls-2.6.0/library/: aes.c
    ../components/cryption/aes/: aes_cbc.c aes_cbc.h
  group components/cryption/crc16
    ../components/cryption/crc16/: crc16.c crc16.h
  group components/cryption/crc32
    ../components/cryption/crc32/: crc32.c crc32.h
  group components/cryption/encry
    ../components/cryption/EncryDecry/: EncryDecry.c EncryDecry.h
  group components/cryption/md5
    ../Middlewares/Third_Party/mbedtls-2.6.0/library/: md5.c
  group components/cryption/rsa
    ../Middlewares/Third_Party/mbedtls-2.6.0/library/: asn1parse.c asn1write.c base64.c bignum.c des.c ecdsa.c ecp.c ecp_curves.c hmac_drbg.c md.c oid.c pem.c pk.c pk_wrap.c pkparse.c ripemd160.c rsa.c
  group components/cryption/sha
    ../Middlewares/Third_Party/mbedtls-2.6.0/library/: md_wrap.c sha1.c sha256.c sha512.c
  group components/err_log
    ../components/err_log/: err_log.c err_log.h
  group components/list
    ../components/list/: m_list.c m_list.h
  group components/log
    ../components/log/: open_log.c open_log.h
  group components/open_door
    ../components/open_door/: open_door.c open_door.h
  group components/permi_list
    ../components/permi_list/: permi_list.c permi_list.h
  group components/socket
    ../components/socket/: socket.c socket.h
  group components/sys_cfg
    ../components/sys_cfg/: sysCfg.c sysCfg.h
  group components/sys_led
    ../components/sys_led/: sys_led.c sys_led.h
  group components/sysCntSave
    ../components/sysCntSave/: sysCntSave.c sysCntSave.h
  group components/tagComp
    ../components/tagComp/: tagComponent.c tagComponent.h
  group components/timer
    ../components/timer/: timer.c timer.h
  group components/twinkle
    ../components/twinkle/: twinkle.c twinkle.h
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/cjson
    ../Middlewares/Third_Party/cjson/: cJSON.c cJSON.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/mqtt
    ../Middlewares/Third_Party/mqtt/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group Middlewares/nanopb
    ../Middlewares/Third_Party/nanopb/: cmd_pb.c cmd_pb.h pb.h pb_common.c pb_common.h pb_decode.c pb_decode.h pb_encode.c pb_encode.h
  group modules
    ../module/ins/: module_ins.h
  group modules/Backlight
    ../module/Backlight/: Backlight.c backlight.h
  group modules/buletooth/bb0906
    ../module/buletooth/BB0906/: bb0906.c bb0906.h bb0906_protocol.c bb0906_protocol.h
  group modules/card/st25/components
    ../module/card/st25r3911b/components/: st25_spi.c st25_spi.h st25_timer.c st25_timer.h st25r3911.c st25r3911.h st25r3911_com.c st25r3911_com.h st25r3911_interrupt.c st25r3911_interrupt.h st_errno.h utils.h
  group modules/card/st25/drv
    ../module/card/st25r3911b/drv/: fkCard.c fkCard.h fm1208.c fm1208.h iso14443a_3.c iso14443a_3.h iso14443bRead.c iso14443bRead.h iso15693Read.c iso15693Read.h st25Drv.c st25Drv.h
  group modules/card/st25/lib
    ../module/card/st25r3911b/Src/: iso14443a.c iso14443a.h iso14443b.c iso14443b.h iso14443b_st25tb.c iso15693_3.c iso15693_3.h mcc.c mcc_crypto.c mcc_crypto_card.c mcc_crypto_reader.c mcc_macros.c mcc_raw_request.c rfal_analogConfig.c rfal_crc.c rfal_crc.h rfal_iso15693_2.c rfal_iso15693_2.h rfal_isoDep.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_rfst25r3911.c rfal_st25tb.c rfal_t1t.c
  group modules/config_key
    ../module/config_key/: config_key.c config_key.h
  group modules/door_key
    ../module/door_key/: door_key.c door_key.h
  group modules/magnet
    ../module/magnet/: magnet.c magnet.h
  group modules/module
    ../module/module/: modules_init.c modules_init.h
  group modules/net/gsm/sim800c
    ../module/net/gsm/sim800c/: sim800c.c sim800c.h
  group modules/net/wifi/esp12s
    ../module/net/wifi/esp12s/: esp12s.c esp12s.h
  group modules/relay
    ../module/relay/: relay.c relay.h
  group modules/spi flash
    ../module/spi_flash/: flash_sector.c flash_sector.h spi_flash.c spi_flash.h
  group utilities
    ../utilities/: cpu_utils.c cpu_utils.h unit.c unit.h
